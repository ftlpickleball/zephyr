## prj.conf
```kconfig
CONFIG_SAMPLE_MOD_VALUE=7
```

## src/main.c
```c
#include <zephyr/kernel.h>
#include "sample_mod.h"

int main(void) {
    return sample_mod_get();
}
```
